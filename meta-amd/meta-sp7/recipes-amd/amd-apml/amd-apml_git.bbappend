LICENSE = "CLOSED"
SRC_URI = "git://git@github.com/amd/apml_library.git;protocol=ssh;tag=apml-3.8.4;branch=master"
unset SRCREV
