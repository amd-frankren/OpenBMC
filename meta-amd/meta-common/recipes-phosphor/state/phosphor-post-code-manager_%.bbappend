EXTRA_OEMESON:append = " \
    -Dmax-boot-cycle-count=5 \
    -Dmax-post-code-size-per-cycle=1024 \
"
