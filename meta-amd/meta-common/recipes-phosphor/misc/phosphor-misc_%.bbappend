FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-phosphor-misc-usb-ctrl-modified-usb-ctrl-script.patch"

