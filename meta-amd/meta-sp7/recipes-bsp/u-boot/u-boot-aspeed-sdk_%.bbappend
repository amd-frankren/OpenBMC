require u-boot-common-sp7_2023.10.inc
