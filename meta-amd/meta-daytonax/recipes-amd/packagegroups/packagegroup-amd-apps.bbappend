#TODO Disabled due to flash size limitation
RDEPENDS_PN_SYSTEM_EXTRAS:remove:daytonax:amd-withhost = "amd-apml"
