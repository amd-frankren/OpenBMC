FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://amd-ast2600-u-boot.cfg"
