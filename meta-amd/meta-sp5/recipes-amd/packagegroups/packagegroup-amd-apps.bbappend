#TODO Remove this once recipes support is in.
RDEPENDS_PN_SYSTEM_EXTRAS:remove:sp5:amd-withhost = "amd-fpga"
RDEPENDS_PN_SYSTEM_MFG:remove:sp5 = "frugen "
