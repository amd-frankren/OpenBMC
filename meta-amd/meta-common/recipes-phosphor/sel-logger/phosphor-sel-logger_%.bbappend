PACKAGECONFIG:append = " log-threshold log-watchdog log-alarm send-to-logger"
