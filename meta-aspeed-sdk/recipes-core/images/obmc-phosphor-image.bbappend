IMAGE_CLASSES:append = " image_types_phosphor_aspeed"
