FILESEXTRAPATHS:prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://sp7.cfg \
	    file://0001-In-order-to-enable-pRoT-re-layout-the-BMC-flash-part.patch \
           "
