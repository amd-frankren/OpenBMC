SNOOP_DEVICE = "aspeed-lpc-pcc0"
POST_CODE_BYTES = "8"
